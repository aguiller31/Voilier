# Keil uVision project application.uvprojx, settings and files
target Simule (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: tp1_Simule
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Drivers\Include;..\Drivers\Src;..\Services\Include;..\ServicesSrc;..\Application
  asm include: ..\..\Drivers\Include;..\..\Drivers\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group MesSources
    ./: conf.h
    ./Source/: app.c main.c
  group Drivers
    ../Drivers/Src/: ADC_Driver.c GPIO_Driver.c TIMER_Driver.c UART_Driver.c Lib_Com_Periph_2022.lib
  group Services
    ../Services/Src/: Communication_Service.c Rotation_Service.c Batterie_Service.c Systick_Service.c Bordage_Service.c Bordage_Service2.c Accelerometre_Service.c RTC_Service.c Girouette_Service.c
target Reel (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: tp1_Simule
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=5 wLevel=3
  c include: ..\Services\Include;..\Drivers\Src;..\Services\Src;..\Drivers\Include;..\Application
  asm include: ..\Drivers\Src;..\Services\Include;..\Drivers\Include;..\Services\Src;..\Application
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.6.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.0.0
