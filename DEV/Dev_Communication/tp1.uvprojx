# Keil uVision project tp1.uvprojx, settings and files
target Simule (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: tp1_Simule
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\MesDrivers;..\..\MesDrivers\Source;..\..\MesDrivers\Include
  asm include: ..\..\MesDrivers\Source;..\..\MesDrivers\Include;..\..\MesDrivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group MesSources
    ./Source/: Principal.c Rotation.c
    ../../MesDrivers/Source/: MyGPIO.c MyTimers.c
target Reel (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: tp1_Simule
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: as above
  asm include: ..\..\MesDrivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.6.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.0.0
